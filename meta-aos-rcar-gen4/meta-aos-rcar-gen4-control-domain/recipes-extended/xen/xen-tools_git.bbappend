RDEPENDS_${PN} += " \
    util-linux-prlimit \
"
