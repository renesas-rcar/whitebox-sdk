VOLATILE_BINDS += "\
    /var/nvme /etc/nvme\n\
"
