COMPATIBLE_HOST= "aarch64.*-linux"

PACKAGE_INSTALL = " \
    initramfs-module-aosupdate \
    initramfs-module-lvm \
    initramfs-module-machineid \
    initramfs-module-nfsrootfs \
    initramfs-module-opendisk \
    initramfs-module-rundir \
    initramfs-module-udev \
    initramfs-module-vardir \
    kernel-module-loop \
    kernel-module-overlay \
    kernel-module-squashfs \
    busybox \
    optee-os \
    optee-client \
    lvm2 \
"
