PACKAGECONFIG_append = " \
    xsm \
"

FILES_${PN}-flask = " \
    /boot/xenpolicy-${XEN_REL}* \
"
