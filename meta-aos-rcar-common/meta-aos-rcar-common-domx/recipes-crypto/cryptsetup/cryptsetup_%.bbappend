# initramfs is build without this lib runtime
RDEPENDS_${PN} += "libgcc"
