export GO111MODULE = "auto"
