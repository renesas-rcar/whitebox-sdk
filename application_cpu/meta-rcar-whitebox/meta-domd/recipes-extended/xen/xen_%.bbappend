PACKAGE_ARCH = "${MACHINE_ARCH}"
COMPATIBLE_MACHINE = "spider|s4sk"
