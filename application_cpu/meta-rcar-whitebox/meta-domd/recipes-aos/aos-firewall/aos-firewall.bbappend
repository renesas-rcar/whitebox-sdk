# GO_IMPORT = "github.com/aosedge/aos_firewall"
GO_IMPORT = "github.com/aosedge/aos_cni_firewall"
