GO_IMPORT = "github.com/aosedge/aos_servicemanager"
