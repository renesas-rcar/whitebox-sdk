GO_IMPORT = "github.com/aosedge/aos_cni_dns"
# GO_IMPORT = "github.com/aosedge/aos_dnsname"
