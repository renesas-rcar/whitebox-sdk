FILESEXTRAPATHS_prepend := "${THISDIR}/optee-os:"

SRC_URI += " \
            file://0001-Add-support-s4sk-for-optee.patch \
            file://0002-FIX-s4sk-for-optee.patch \
"
