FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_spider = " \
    file://early_printk_s4sk.cfg \
"

