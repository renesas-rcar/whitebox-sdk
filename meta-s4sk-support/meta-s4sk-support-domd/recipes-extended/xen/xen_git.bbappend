FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:s4sk = " \
    file://early_printk_s4sk.cfg \
"

