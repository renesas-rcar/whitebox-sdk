
COMPATIBLE_MACHINE := "(spider|s4sk|generic-armv8-xt)"

