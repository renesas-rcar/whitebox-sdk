EXTRA_OECONF += " \
    --enable-ipcdir=/run/pcscd \
"

