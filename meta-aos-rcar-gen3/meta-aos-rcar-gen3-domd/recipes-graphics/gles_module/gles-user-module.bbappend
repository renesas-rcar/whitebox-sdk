FILESEXTRAPATHS_append = "${TOPDIR}/../../../../../prebuilt_gsx/domd:"

PROVIDES:append = " virtual/libgl"

FILES_${PN}_append = " /lib/firmware/*"

