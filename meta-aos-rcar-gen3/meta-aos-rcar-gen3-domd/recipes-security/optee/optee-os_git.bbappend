# Move tee.bin into 'firmware' folder
inherit collect_firmware
